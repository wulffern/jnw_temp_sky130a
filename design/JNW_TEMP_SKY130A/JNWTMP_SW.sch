v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/code_shown.sym} -70 -20 0 0 {name=s1 only_toplevel=false value="xsw P N C VDD_1V8 VSS cpdk_ideal_switch RON=1k"}
C {devices/ipin.sym} -130 -160 2 1 {name=p2 lab=P}
C {devices/opin.sym} -130 -110 2 1 {name=p3 lab=N}
C {devices/ipin.sym} -130 -230 2 1 {name=p4 lab=VDD_1V8}
C {devices/ipin.sym} -130 -10 2 1 {name=p5 lab=VSS}
C {devices/ipin.sym} -130 -70 2 1 {name=p1 lab=C}
